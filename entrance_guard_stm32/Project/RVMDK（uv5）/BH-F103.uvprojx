# Keil uVision project BH-F103.uvprojx, settings and files
target rc522 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gp2y +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\flash;..\..\User\font;..\..\User\lcd;..\..\User\RC522;..\..\User\SysTick;..\..\User\usart;..\..\User\timer;..\..\User\exti;..\..\User\timer2;..\..\User\dht11;..\..\User\dwt_delay;..\..\User\MLX90614;..\..\User\Led;..\..\User\myled;..\..\User\ESP8266;..\..\User\Common;..\..\User\Test;..\..\User\pelette
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/Lcd/: bsp_ili9341_lcd.c
    ../../User/usart/: bsp_usart.c
    ../../User/font/: fonts.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/RC522/: rc522_config.c rc522_function.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/timer/: timer.c
    ../../User/exti/: bsp_exti.c
    ../../User/timer2/: timer2.c
    ../../User/dht11/: bsp_dht11.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/MLX90614/: mlx90614.c
    ../../User/Led/: bsp_led.c
    ../../User/myled/: my_led.c
    ../../User/Common/: Common.c
    ../../User/ESP8266/: bsp_esp8266.c
    ../../User/Test/: test.c
    ../../User/pelette/: palette.c
    ../../User/lcd/: bsp_xpt2046_lcd.c
  group DOC
    ../../Doc/: readme.txt
